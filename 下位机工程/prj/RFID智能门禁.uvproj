# Keil uVision project RFID智能门禁.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F60XE STC11F32XE Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: RFID智能门禁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../code/: ctrl.c flash.c key.c lcd12864.c main.c rc522.c timer.c uart.c
